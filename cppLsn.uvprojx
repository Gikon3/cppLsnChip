# Keil uVision project cppLsn.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: cppLsn
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\include
  memory RVCT4: ROM 0x10000000 size 0x1ffff
  memory RVCT9: RAM 0x10020000 size 0x1ffff
  group system
    ./system/: startup_cppLsn.s system_cppLsn.c
  group periph
    ./periph/: rc.c cg.c tmr.c spim1.c spim4.c i2cm.c spiqf.c spod.c uart.c gpio.c
  group user
    ./user/: main.c poll.c interrupt.c memory_poll.c periph_poll.c
software components: CMSIS:CORE 5.4.0
